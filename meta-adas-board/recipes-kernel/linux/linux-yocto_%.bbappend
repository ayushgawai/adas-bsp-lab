FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://adas-virt.dts"
KERNEL_DEVICETREE = "adas-virt.dtb"
